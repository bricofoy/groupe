# Repository bricofoy/groupe

## KiCad design kicad/groupe2/groupe2.kicad_pcb

Parts:
C1, C7, C8, C9, C10, C11: 100n; cnp_18x6mm
C2: 10 000 µ; C1V5
C3: 1µ; C1V5
C4: 120µ; C1V8
C5, C6: 22p; cnp_18x6mm
C12: 68n; cnp_18x6mm
C13: 100µ; C1V8
D1, D2, D3, D4, D5, D10, D11: 1N4007; D3
D6, D7, D8, D9: 1N4004; D3
F1: 5A; fus_auto_3522-2
F2: 7,5A; fus_auto_3522-2
F3: 20A; fus_auto_3522-2
F4, F5: 10A; fus_auto_3522-2
P1: Pwr; bornier4
P2: ext; bornier2
P3: +; borne_vis_Keystone_7698
P4: -; borne_vis_Keystone_7698
P5: Chg; borne_vis_Keystone_7698
P6: Sorties; bornier4
P7: LEDs; bornier4
P8: reset; bornier2
P9: sTTL
P10: 220V; bornier2
Q1, Q2, Q3, Q4, Q5: IRF740; TO220V-GDS
Q6, Q7, Q8: 2N2222; TO92-123
R1, R3, R5, R7, R9, R15, R16, R20, R24, R27: 1k; R3
R2, R18, R19, R21: 8.2k; R3
R4, R6, R8, R10, R17: 22k; R3
R11: 220k; R3
R12, R13, R14: 10k; R3
R22: 1M; R3
R23, R34: 100; R3
R25, R26, R28, R29: 15k; R3
R30, R31, R32: 4.7k; R3
R33: 47M; R3
R35: 300; R3
RL1: EV; relais_auto_1R_faston_TE_1217080-1
RL2: Demarreur; relais_auto_1R_faston_TE_1217080-1
RL3: Prechauf; relais_auto_1R_faston_TE_1217080-1
RL4: Decomp; relais_auto_1R_faston_TE_1217080-1
RL5: 95.15.2; relay_finder-95.15.2
SW1: RESET
U1: 7805
U2: ATMEGA328-P; DIL28
U3: KB817; opto_dil4
X1: CRYSTAL

Connections:
+5V: C3.1, C7.2, C9.2, R12.1, R13.1, R14.1, R24.1, U1.VO, U2.7 (VCC), U2.20 (AVCC)
+12V: D1.2 (K), D2.2 (K), D3.2 (K), D4.2 (K), D8.1 (A), P5.1, P7.1, RL1.1, RL2.1, RL3.1, RL4.1, RL5.24
+BATT: F1.1, F2.1, F3.1, F4.1, F5.1, P3.1
/RX: P9.1, U2.2 ((RX)D00)
/TX: P9.2 (PM), U2.3 ((TX)D01)
/e_alim_ubat: C10.1, R25.1, RL5.14
/e_ext: C11.1, D7.1 (A), P2.1, R26.1
/e_local: D6.1 (A), P1.3, R28.1
/e_prh: P1.4, R23.1
/e_rst: P8.1, R29.1, U2.5 ((INT1)*D03)
/e_run: R27.2, U3.4 (C)
/s_EV: R3.2, U2.16 ((~SS~)*D10)
/s_OK: Q6.2 (B), R18.1
/s_alim: R1.1, U2.19 ((SCK)D13)
/s_alrm: Q7.2 (B), R19.1
/s_dcmp: R9.2, U2.15 (*D09)
/s_dem: R5.2, U2.17 ((MOSI)*D11)
/s_led_alim: Q8.2 (B), R21.1
/s_prch: R7.2, U2.18 ((MISO)D12)
GND: C1.1, C2.2, C3.2, C5.1, C6.1, C7.1, C8.1, C9.1, C10.2, C11.2, P4.1, P9.3, Q1.S, Q2.S, Q3.S, Q4.S, Q5.S, Q6.1 (E), Q7.1 (E), Q8.1 (E), R4.2, R6.2, R8.2, R10.2, R17.2, R29.2, R30.2, R31.2, R32.2, SW1.1, U1.GND, U2.8 (GND), U2.22 (AGND), U3.3 (E)
unnamed: D3.1 (A), Q3.D, RL3.2
unnamed: D1.1 (A), Q1.D, RL1.2
unnamed: F2.2, RL2.3
unnamed: F4.2, RL4.3
unnamed: Q2.G, R5.1, R6.1
unnamed: D4.1 (A), Q4.D, RL4.2
unnamed: Q3.G, R7.1, R8.1
unnamed: P7.3, R16.1
unnamed: P7.2, R15.1
unnamed: D9.1 (A), R1.2
unnamed: P7.4, R20.1
unnamed: Q4.G, R9.1, R10.1
unnamed: C4.1, R2.2, R11.1
unnamed: C4.2, D9.2 (K), Q5.G, R11.2, R17.1
unnamed: D5.1 (A), Q5.D, RL5.A2
unnamed: P6.3, RL2.5
unnamed: P6.1, RL4.5
unnamed: P1.2, P2.2 (PM), RL5.11
unnamed: Q6.3 (C), R15.2
unnamed: Q7.3 (C), R16.2
unnamed: Q1.G, R3.1, R4.1
unnamed: F3.2, RL3.3
unnamed: F1.2, RL1.3
unnamed: D2.1 (A), Q2.D, RL2.2
unnamed: D6.2 (K), D7.2 (K), R2.1
unnamed: P6.2, RL3.5
unnamed: P6.4, RL1.5
unnamed: D5.2 (K), F5.2, P1.1, RL5.21, RL5.A1
unnamed: R13.2, R23.2, U2.4 ((INT0)D02)
unnamed: C8.2, U2.21 (AREF)
unnamed: R25.2, R32.1, U2.23 (A0)
unnamed: R28.2, R30.1, U2.26 (A3)
unnamed: R26.2, R31.1, U2.24 (A1)
unnamed: C13.1, D10.2 (K), R34.1
unnamed: R34.2, U3.1 (A)
unnamed: R14.2, R27.1, U2.25 (A2)
unnamed: C12.2, P10.2 (PM), R33.1
unnamed: C12.1, R33.2, R35.1
unnamed: C1.2, C2.1, D8.2 (K), U1.VI
unnamed: R18.2, U2.14 (D08)
unnamed: R19.2, U2.13 (D07)
unnamed: P8.2 (PM), R24.2
unnamed: C13.2, D11.1 (A), P10.1, U3.2 (K)
unnamed: D10.1 (A), D11.2 (K), R35.2
unnamed: Q8.3 (C), R20.2
unnamed: R21.2, U2.12 (*D06)
unnamed: R12.2, SW1.2, U2.1 (~RESET~)
unnamed: C6.2, R22.2, U2.10 (XTAL2), X1.1
unnamed: C5.2, R22.1, U2.9 (XTAL1), X1.2

Notes on the sheet:
Détection fonctionnement moteur
Attention, présence tension 240V sur cette partie du circuit.

Board: 2 copper layers, 92 parts (0 on the bottom side), 69 nets.

## Code that names these connections

File groupe.ino (part):

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#include <EEPROM.h>

//broches de sortie
#define s_alim	13	//Maintien alim
#define s_ev	12	//EV contact
#define s_dem	10	//Demarreur
#define s_pre	 9	//Préchauffage
#define s_out	11	//Relais de coupure sortie puissance
#define s_alarme 7	//Témoin d'alerte
#define s_ok	 8	//Témoin OK

//valeurs des sorties
#define vs_alim	   1	//format : alim|EV|demarreur|prechaufage|sortie|0|alerte|ok
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#define vs_ok	 128

//broches d'entrées
#define e_alim_ubat	A0	//Alim et tension batterie
#define e_ext		A1	//Commande externe
#define e_prh		2	//Pression huile
#define e_run		A3	//1 si moteur en route
#define e_rst		3	//entrée reset alarme
#define e_loc		A2	//entrée commande locale

//valeurs des entrées
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
  Serial.begin(9600);
  
  pinMode(s_alim,  OUTPUT);
  pinMode(s_alarme,OUTPUT);
  pinMode(s_pre,   OUTPUT);
  pinMode(s_dem,   OUTPUT); 
  pinMode(s_out,   OUTPUT);
  pinMode(s_ok,    OUTPUT);
  pinMode(s_ev,    OUTPUT);
  
  pinMode(e_alim_ubat, INPUT);
  pinMode(e_ext,  INPUT); 
  pinMode(e_prh,  INPUT);
  //digitalWrite(e_prh, HIGH); 			//Active la resistance de pull-up interne
  //pinMode(e_ubat, INPUT);
  pinMode(e_run,  INPUT);
  pinMode(e_rst,  INPUT);
  pinMode(e_loc,  INPUT);
  
  digitalWrite(s_alim, HIGH); 			//Auto-maintien du relais d'alimentation
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
## Commit log

2013-01-15 commit initial depuis l'état courant du projet
2013-02-11 version 0.9.9 :
    suppression erreur temps maintenance + plein d'autres trucs
    ajout test si ve_alim avant vérifier ubat pour éviter fausse erreur
    VERSION QUI FONCTIONNE !!
2013-03-05 nouvelle version fichier pcb kicad
2013-03-05 essai
2013-03-05 fin essai
2013-03-22 Baisse seuil detection "alim"
2013-05-07 30-04-2013 | bricofoy@free.fr | 1.0.0 | Ajout tempo de chauffage et refroidissement moteur + commande relais | | | coupure sortie commandé par s_dec (mais tout ça c'est pas fini !! en fait juste des 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
2013-05-10 Version 1.0.0
    Ajout tempo de chauffage et refroidissement moteur + commande relais coupure sortie commandé par s_out
    renommage s_dec --> s_out vs_decmp --> vs_out
    ajout tempo sur détection défaut PrH pour éviter détection PrH au lieu de calage
2013-05-10 presque fini
2013-05-11 1.0.0 finale qui fonctionne
2013-05-13 1.0.0 finale qui fonctionne
    -démarrage sur commande externe, moteur tourne min avant activation sortie, puis 3min après coupure sortie lorsque la demande disparait.
    -si la demande revient avant arret moteur -> réactivation sortie immédiate
    -lors des phase de chauffe et refroidissement moteur, la diode verte clignote. clignotement lent pdt la chauffe, rapide pdt le refroidissement.
2013-05-15 corrections de formattage pour faciliter la lecture du code
2013-05-16 Mise à jour du fichier utilisation.
    Mise à jour du fihier utilisation pour correspondre au comportement de la version 1.0.0
    Supression de deux fichier obsolètes.

Notices in the files:
groupe.ino:
Programme sous licence GNU GPL
